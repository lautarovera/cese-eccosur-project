# IAR project Sample_Bootloader.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: config\linker\lnk430_FRAM_RAM_1C00-1FFF.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group Config/Linker
    config/linker/: lnk430_FRAM_RAM_1C00-1FFF.xcl
