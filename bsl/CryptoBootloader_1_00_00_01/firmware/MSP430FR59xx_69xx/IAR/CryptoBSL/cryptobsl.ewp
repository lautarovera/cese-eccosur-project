# IAR project cryptobsl.ewp, settings and files
configuration FR5969_Crypto (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: FULL_STANDARD_COMMANDS=0; CRYPTO_COMMANDS=1; NDEBUG
  ICC430.newCCIncludePaths: ..\..\Src; ..\..\..\CryptoBSL\BSL430_API; ..\..\..\CryptoBSL\BSL430_Command_Interpreter; ..\..\..\CryptoBSL\BSL430_Peripheral_Interface; ..\..\..\CryptoBSL\BSL430_Peripheral_Interface\eUSCI_UART; ..\..\..\CryptoBSL\BSL430_Crypto; ..\..\..\CryptoBSL\BSL430_Crypto\cipher; ..\..\..\CryptoBSL\BSL430_Crypto\mode; ..\..\..\CryptoBSL\BSL430_Crypto\utils; ..\..\..\CryptoBSL\BSL430_Crypto\mac
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL=1
  A430.AUserIncludes: ..\..\Src
  XLINK.XclFile: CONFIG\lnk430_FRAM_RAM_1C00-1FFF.xcl
  XLINK.XlinkStackSize: 1
configuration FR5969_StandardwCrypto (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: FULL_STANDARD_COMMANDS=1; CRYPTO_COMMANDS=1; NDEBUG
  ICC430.CCOptStrategy: 1
configuration FR5994_Crypto (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
configuration FR5994_StandardwCrypto (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  ICC430.CCDefines: FULL_STANDARD_COMMANDS=1; CRYPTO_COMMANDS=1; NDEBUG
  ICC430.CCOptStrategy: 1
configuration FR6989_Crypto (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR6989 MSP430FR6989
configuration FR6989_StandardwCrypto (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR6989 MSP430FR6989
  ICC430.CCDefines: FULL_STANDARD_COMMANDS=1; CRYPTO_COMMANDS=1; NDEBUG
  ICC430.CCOptStrategy: 1
  group CryptoBSL/API
    ../../../CryptoBSL/BSL430_API/: BSL430_API.h BSL430_API_FRAM_CRYPTO.c BSL430_API_MassErase.s43
  group CryptoBSL/Command_Interpreter
    ../../../CryptoBSL/BSL430_Command_Interpreter/: BSL430_Command_Definitions.h BSL430_Command_Interpreter.c BSL430_Command_Interpreter.h
  group CryptoBSL/Crypto
    ../../../CryptoBSL/BSL430_Crypto/: BSL430_Crypto.c BSL430_Crypto.h BSL430_Crypto_Config.h
  group CryptoBSL/Crypto/cipher
    ../../../CryptoBSL/BSL430_Crypto/cipher/: aes.h aes_hw.c
  group CryptoBSL/Crypto/mac
    ../../../CryptoBSL/BSL430_Crypto/mac/: cbc_mac.c cbc_mac.h
  group CryptoBSL/Crypto/mode
    ../../../CryptoBSL/BSL430_Crypto/mode/: aes_ccm.c aes_ccm.h ctr.c ctr.h
  group CryptoBSL/Crypto/utils
    ../../../CryptoBSL/BSL430_Crypto/utils/: utils.c utils.h
  group CryptoBSL/Peripheral_Interface
    ../../../CryptoBSL/BSL430_Peripheral_Interface/: BSL430_PI.h
  group CryptoBSL/Peripheral_Interface/eUSCI_UART_I2C
    ../../../CryptoBSL/BSL430_Peripheral_Interface/eUSCI_UART_I2C/: BSL430_PI_eUSCI_UART_I2C.c
  group MSP430FR59xx_69xx
    ../../Src/: .symlink BSL_Device_File.h ipe.s43
  group MSP430FR59xx_69xx/CONFIG
    CONFIG/: lnk430_FRAM_RAM_1C00-1FFF.xcl
