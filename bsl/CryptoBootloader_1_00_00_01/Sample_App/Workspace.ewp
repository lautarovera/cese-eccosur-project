# IAR project Workspace.ewp, settings and files
configuration FR5969 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: config\linker\lnk430fr5969_CryptoBSL.xcl
  XLINK.XlinkStackSize: 1
configuration FR6989 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR6989 MSP430FR6989
  XLINK.XclFile: config\linker\lnk430fr6989_CryptoBSL.xcl
configuration FR5994 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  XLINK.XclFile: config\linker\lnk430fr5994_CryptoBSL.xcl
  group (top)
    ./: main.c
  group Config/Linker
    config/linker/: lnk430fr5969_CryptoBSL.xcl lnk430fr5994_CryptoBSL.xcl lnk430fr6989_CryptoBSL.xcl
